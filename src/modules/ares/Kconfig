## src/modules/ares/Kconfig
```kconfig
menuconfig MODULES_ARES
	bool "ares"
	default n
	---help---
		enable ares gnc module
```
